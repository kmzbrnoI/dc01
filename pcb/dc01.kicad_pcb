# Repository kmzbrnoI/dc01

File README.md:

DCC cutter DC-01
================

DC-01 is a DCC-cutting device. It can dis/connect low-power DCC signal. DC-01
is connected to a PC via USB. Its purpose is to serve as a *safety device* – PC
application monitors railroad control software running on the PC. When software
malfunctions (no data are received from the SW for some time), DC-01 cuts DCC
so all the trains operated by the malfunctioning SW are immediately stopped.

This project contains both PCB manufacturing data and firmware for PCB's MCU.

## Features

* DC-01 connects to PC via CDC USB-C. Communication goes over standard serial
  port. It is possible to automatically detect which serial interface is DC-01 in
  Linux & Windows, see software in `sw` subfolder.
* DC-01 contains 2 2-pole relays. DCC is connected in *active* relays state
  (disconnected when powered off). Each relay disconnects both DCC wires, relays
  are serially coupled. In case of malfunction, disconnection of just one of 4
  contacts is enough for DCC cut.
* DC-01 contains self-testing equipment. Selftests are programmed in the
  firmware of DC-01, their result is reported to PC.
* Relays are controlled via monostable multivibrators. MCU on DC-01 must
  generate dynamic signal to keep relays on. When processor freezes or
  malfunctions, relays are safely disconnected.
* There are PTCs on DCC wires.
* STM32F103 MCU, USB-C connector, RJ-12 as well as screw terminal blocks for
  DCC connection, galvanically isolated output report signals, report LEDs,
  manual on/off buttons, ESD protection on USB, powered only from USB.

## PCB

See [README in `pcb` subfolder](pcb/README.md).

## Firmware

See [README in `fw` subfolder](fw/README.md).

## Software

[PC console application in Python](sw) is provided. This application connects to
DC-01 & hJOP, it monitors hJOP. When hJOP dies or requests DCC disconnect
DCC is disconnected via DC-01.

## External acoustic warning

See [README in `aco-warn` subfolder](aco-warn/README.md).

## Further reading

Functionality of DC-01 is described in [this article](https://www.kmz-brno.cz/dc01/)
(czech language only).

## Authors

DC-01 was created by a member of [Model Railroaders Club
Brno](https://www.kmz-brno.cz/), [Jan Horáček](mailto:jan.horacek@kmz-brno.cz).

## Licence

See README in subfolders for licenses regarding pcb design and software.

## KiCad design pcb/dc01.kicad_pcb

File pcb/README.md:

DC-01 PCB
=========

## Design

Schematics & PCB are designed in KiCad 6.

## Production

PCB is prepared to be automatically assembled in [JLCPCB](https://jlcpcb.com/).
SMD parts on **top** side should be assembled. Each SMD part has its `LCSC_ITEM`
attribute set.

```bash
$ make fab
```

## License

Content of this directory is provided under [Creative Commons
Attribution-ShareAlike 4.0
License](https://creativecommons.org/licenses/by-sa/4.0/) as openhardware
project. You may download any data, contribute to the project, create PCB
yourself or even sell it yourself.

Parts:
C1, C2, C5, C6, C7: 100n; C_0805_2012Metric; LCSC C49678
C3, C4: 22p; C_0805_2012Metric; LCSC C1804
C8: 10u; C_0805_2012Metric; LCSC C15850
C9: 22u; C_0805_2012Metric; LCSC C45783
D1, D15: GR; LED_0805_2012Metric; LCSC C2297
D2, D14: YEL; LED_0805_2012Metric; LCSC C2296
D3, D16: RED; LED_0805_2012Metric; LCSC C84256
D4: BLUE; LED_0805_2012Metric; LCSC C2293
D7: ESDA6V1-5SC6; SOT-23-6; LCSC C6650
H1, H2, H3: -; jlcpcb_tooling_holes; JLCPCB_IGNORE true
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_HRO_TYPE-C-31-M-12; LCSC C165948
J2: PROG/DEBUG; PinHeader_2x05_P2.54mm_Vertical; JLCPCB_IGNORE true
J3: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical; JLCPCB_IGNORE true
J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical; JLCPCB_IGNORE true
J9, J10: MV132; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal; JLCPCB_IGNORE true
JP1, JP4: SJ_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm; JLCPCB_IGNORE true
JP2: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm_NumberLabels; JLCPCB_IGNORE true
JP3: Jumper; PinHeader_1x02_P2.54mm_Vertical; JLCPCB_IGNORE true
R1, R2: 5k1; R_0805_2012Metric; LCSC C27834
R3, R4, R16, R18, R19, R21: 10k; R_0805_2012Metric; LCSC C17414
R5, R6, R20, R22: 1k; R_0805_2012Metric; LCSC C17513
R7: 2k2; R_0805_2012Metric; LCSC C17520
R17: 1k5; R_0805_2012Metric; LCSC C4310
R23, R24: 470R; R_0805_2012Metric; LCSC C17710
SW1, SW2: SW_Push; SW_PUSH_6mm_H4.3mm; JLCPCB_IGNORE true
SW3: MFP 113 D; SW_Slide_1P2T_CK_OS102011MS2Q; JLCPCB_IGNORE true
TP1: TestPoint; TestPoint_Loop_D3.50mm_Drill1.4mm_Beaded; JLCPCB_IGNORE true
U1: STM32F103C8Tx; LQFP-48_7x7mm_P0.5mm; LCSC C8734
U2: AMS1117-3.3; SOT-223-3_TabPin2; LCSC C6186
U3, U4: PC817; DIP-4_W8.89mm_SMDSocket_LongPads; LCSC C106900
Y1: 8 MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm; LCSC C115962

Connections:
+3V3: C2.2, C5.2, C6.2, C7.2, C9.1, JP1.1 (A), JP2.3 (B), JP3.2 (B), R16.2, R18.2, R19.2, R20.2, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.2 (VO); also elsewhere on the board
+5V: C8.2, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), JP2.1 (A), JP4.1 (A), U2.3 (VI); also elsewhere on the board
/BOOT: JP3.1 (A), R4.2, U1.44 (BOOT0)
/IO1DCC: U1.18 (PB0); also elsewhere on the board
/IO2DCC: U1.19 (PB1); also elsewhere on the board
/LED_BLUE: R7.2, U1.25 (PB12)
/LED_GO: R21.2, U1.22 (PB11)
/LED_GR: R3.2, U1.28 (PB15)
/LED_RED: R6.2, U1.26 (PB13)
/LED_STOP: R22.2, U1.21 (PB10)
/LED_YEL: R5.2, U1.27 (PB14)
/REL1CTRL: U1.20 (PB2); also elsewhere on the board
/REL2CTRL: U1.39 (PB3); also elsewhere on the board
/SW_GO: R16.1, SW1.2, U1.43 (PB7)
/SW_OVERRIDE: D14.1 (K), R19.1, SW3.3 (C), U1.46 (PB9)
/SW_STOP: R18.1, SW2.2, U1.45 (PB8)
DBG_CTS: J3.5, U1.10 (PA0)
DBG_RX: J3.3, U1.13 (PA3)
DBG_TX: J3.2, U1.12 (PA2)
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, C8.1, C9.2, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D7.2 (GND), D15.1 (K), D16.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J2.3, J2.4, J3.6, R1.1, R2.2, R4.1, SW1.1, SW2.1, SW3.2 (B), TP1.1, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.1 (GND), U3.2, U4.2; also elsewhere on the board
unnamed: C3.1, U1.5 (PD0), Y1.2
unnamed: C4.2, U1.6 (PD1), Y1.1
unnamed: D1.2 (A), R3.1
unnamed: D2.2 (A), R5.1
unnamed: D3.2 (A), R6.1
unnamed: D4.2 (A), R7.1
unnamed: D14.2 (A), R20.1
unnamed: D15.2 (A), R21.1
unnamed: D16.2 (A), R22.1
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.2
unnamed: J2.7, J2.8, JP1.2 (B)
unnamed: J2.9, J2.10, JP4.2 (B)
unnamed: J3.4, JP2.2 (C)
unnamed: J8.1, U1.29 (PA8)
unnamed: J8.2, U1.30 (PA9)
unnamed: J9.1, U3.4
unnamed: J9.2, U3.3
unnamed: J10.1, U4.4
unnamed: J10.2, U4.3
unnamed: R17.2, U1.31 (PA10)
unnamed: R23.2, U3.1
unnamed: R24.2, U4.1
OUT_ALERT: R24.1, U1.41 (PB5)
OUT_ON: R23.1, U1.42 (PB6)
RST: C1.2, J2.1, U1.7 (NRST)
SWCLK: J2.6, U1.37 (PA14)
SWDIO: J2.2, U1.34 (PA13)
USBD+: D7.6 (IO5), J1.A6 (D+), J1.B6 (D+), R17.1, U1.33 (PA12)
USBD-: D7.4 (IO3), J1.A7 (D-), J1.B7 (D-), U1.32 (PA11)

Notes on the sheet:
JLCPCB tooling holes
USB specification allows max 10u

Parts:
C14, C15, C16: 100n; C_0805_2012Metric; LCSC C49678
R27, R28: 47k; R_0805_2012Metric; LCSC C17713
R31, R32: 10k; R_0805_2012Metric; LCSC C17414
U7: 74HC123; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C91435

Connections:
+3V3: C15.1, R27.1, R28.1, U7.3 (Clr), U7.11 (Clr), U7.16 (VCC); also elsewhere on the board
/DCC cutting/REL1CTRL: U7.13 (Q); also elsewhere on the board
/DCC cutting/REL2CTRL: U7.5 (Q); also elsewhere on the board
/REL1CTRL: R31.2, U7.2 (B); also elsewhere on the board
/REL2CTRL: R32.2, U7.10 (B); also elsewhere on the board
GND: C14.2, C15.2, C16.2, R31.1, R32.1, U7.1 (A), U7.6 (Cext), U7.8 (GND), U7.9 (A), U7.14 (Cext); also elsewhere on the board
unnamed: C14.1, R27.2, U7.15 (RCext)
unnamed: C16.1, R28.2, U7.7 (RCext)

Notes on the sheet:
Pulse width: ~2.4 ms

Parts:
C10, C11: 10n; C_0805_2012Metric; LCSC C1710
C12, C13: 10u; C_0805_2012Metric; LCSC C15850
D5, D6, D10, D11, D17, D18, D19, D20, D21, D22: 1N5819; D_SOD-123; LCSC C8598
D8, D9: GR; LED_0805_2012Metric; LCSC C2297
D12, D13: BLUE; LED_0805_2012Metric; LCSC C2293
F1, F2: 1A; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder; JLCPCB_IGNORE true
J4, J5: RJ12; RJ25_Wayconn_MJEA-660X1_Horizontal; JLCPCB_IGNORE true
J6, J7: MV132; TerminalBlock_4Ucon_1x02_P3.50mm_Horizontal; JLCPCB_IGNORE true
K1, K2: AZ850-5; Relay_DPDT_FRT5; JLCPCB_IGNORE true
Q1, Q2: 2N7002; SOT-23; LCSC C8545
R8, R9, R15, R25: 10k; R_0805_2012Metric; LCSC C17414
R10, R11, R14, R26: 2k2; R_0805_2012Metric; LCSC C17520
R12, R13, R29, R30: 1k; R_0805_2012Metric; LCSC C17513
R33, R34: 47k; R_0805_2012Metric; LCSC C17713
U5, U6: PC817; DIP-4_W8.89mm_SMDSocket_LongPads; LCSC C106900

Connections:
+3V3: R8.2, R9.2; also elsewhere on the board
+5V: C12.1, C13.1, D10.1 (K), D11.1 (K), K1.1, K2.1; also elsewhere on the board
/DCC cutting/J1: D5.2 (A), D6.1 (K), J4.1, J6.1, K1.8
/DCC cutting/J2: F1.2, J5.1, J7.1
/DCC cutting/K1: D19.2 (A), D20.1 (K), J4.6, J6.2, K1.3
/DCC cutting/K2: F2.2, J5.6, J7.2
/DCC cutting/REL1CTRL: R12.2, R14.1, R15.1; also elsewhere on the board
/DCC cutting/REL2CTRL: R13.2, R25.1, R26.1; also elsewhere on the board
/DCC cutting/TW2: J4.2, J5.2
/DCC cutting/TW3: J4.3, J5.3
/DCC cutting/TW4: J4.4, J5.4
/DCC cutting/TW5: J4.5, J5.5
/IO1DCC: R29.1; also elsewhere on the board
/IO2DCC: R30.2; also elsewhere on the board
GND: C12.2, C13.2, D12.1 (K), D13.1 (K), Q1.2 (S), Q2.2 (S), R15.2, R25.2, U5.3, U6.3; also elsewhere on the board
unnamed: C10.1, D5.1 (K), D19.1 (K), R33.2, U5.1
unnamed: C10.2, D6.2 (A), D8.1 (K), D20.2 (A), R10.1
unnamed: C11.1, D9.1 (K), D17.2 (A), D21.2 (A), R11.1
unnamed: C11.2, D18.1 (K), D22.1 (K), R34.2, U6.1
unnamed: D8.2 (A), R33.1
unnamed: D9.2 (A), R34.1
unnamed: D10.2 (A), K1.10, Q1.3 (D)
unnamed: D11.2 (A), K2.10, Q2.3 (D)
unnamed: D12.2 (A), R14.2
unnamed: D13.2 (A), R26.2
unnamed: D17.1 (K), D18.2 (A), F1.1, K2.8
unnamed: D21.1 (K), D22.2 (A), F2.1, K2.3
unnamed: K1.4, K2.4
unnamed: K1.7, K2.7
unnamed: Q1.1 (G), R12.1
unnamed: Q2.1 (G), R13.1
unnamed: R10.2, U5.2
unnamed: R11.2, U6.2
unnamed: R8.1, R29.2, U5.4
unnamed: R9.1, R30.1, U6.4

Board: 4 copper layers, 76.0 x 84.0 mm, 107 parts (0 on the bottom side), 82 nets.

## Code that names these connections

File fw/inc/gpio.h:

/* Low-level GPIO functions, pin definitions. */

#pragma once

#include <stdbool.h>
#include "stm32f1xx_hal.h"

typedef struct {
	GPIO_TypeDef* port;
	uint32_t pin;
} PinDef;

static inline bool pindef_eq(PinDef a, PinDef b) {
	return (a.port == b.port) && (a.pin == b.pin);
}

extern const PinDef pin_led_red;
extern const PinDef pin_led_green;
extern const PinDef pin_led_blue;
extern const PinDef pin_led_yellow;

extern const PinDef pin_usb_dn;
extern const PinDef pin_usb_dp;
extern const PinDef pin_usb_dp_pullup;

extern const PinDef pin_btn_override;
extern const PinDef pin_btn_go;
extern const PinDef pin_led_go;
extern const PinDef pin_btn_stop;
extern const PinDef pin_led_stop;

extern const PinDef pin_out_alert;
extern const PinDef pin_out_on;

extern const PinDef pin_dcc1;
extern const PinDef pin_dcc2;

extern const PinDef pin_relay1;
extern const PinDef pin_relay2;

extern const PinDef pin_debug_a;
extern const PinDef pin_debug_b;

extern const PinDef pin_debug_cts;
extern const PinDef pin_debug_tx;
extern const PinDef pin_debug_rx;

void gpio_init(void);

void gpio_pin_init(PinDef pin, uint32_t mode, uint32_t pull, uint32_t speed, bool de_init_first);
bool gpio_pin_read(PinDef pin);
void gpio_pin_write(PinDef pin, bool value);
void gpio_pin_toggle(PinDef pin);

## Commit log (part)

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2023-01-22 Add KiCad .gitignore.
2023-01-22 Import schematics & pcb from MTB-USB-4.
2023-01-22 Rename dcc-cutter to dc01.
2023-01-22 Remove unused parts.
2023-01-22 Add & wire relay part.
2023-01-22 Add relay-power indication LEDs.
2023-01-22 Add buttons.
2023-01-22 Add override switch.
2023-01-22 Add parts, several minor enhancements.
2023-01-22 Add jlcpcb tooling holes library.
2023-01-25 Add outputs.
2023-01-25 Add footprints.
2023-01-25 Add empty readme.
2023-01-25 Add LICENSE.
2023-01-25 Reorder schematics.
2023-01-25 Move pcb files to separate directory.
2023-01-25 Move readme to root.
2023-01-25 Switch relay indication LEDs & resistors.
2023-01-25 Divide into more sheets. Use relays in series.
2023-01-25 Fix ERC.
2023-01-25 Add subschematics, add footprints.
2023-01-30 Use dicrete schottky diodes for dcc rectifiers.
    Schottky diodes do not cause short-time shortcuts.
2023-01-30 Add optocouplers output protection resistors.
2023-01-30 Use proper value for screw terminals.
2023-02-01 Use MV132 as screw terminals.
2023-02-01 Clean up PCB (from MTB-USB v4).
2023-02-03 Draw & route part of PCB.
2023-02-04 Route another part of PCB.
2023-02-05 Wire everything.
2023-02-05 Silkscreen.
2023-02-22 Tweak tracks width, silkscreen, GND vias.
2023-02-22 Fix DRC errors.
2023-02-26 Minor silkscreen tweaks.
2023-02-26 Add LCSCs.
2023-02-26 Add Makefile for jlcpcb fabrication data.
2023-02-26 Do not use 2 different types of diodes.
2023-02-26 Tweak silkscreen.
2023-02-26 Add meaningful contents of readme.
2023-03-05 Conn → screw terminals.
2023-04-20 Add pull-down resistors to relay logic signals.
2023-06-07 Add FW template based on MTB-USB-4-FW.
2023-06-07 Add GPIO for DC-01.
2023-06-07 CDC for DC-01.
2023-06-07 Remove old MTB-USB stuff.
2023-06-07 Update project name.
2023-06-07 FW works on device.
2023-06-07 Make prototype of relay control work.
2023-06-07 Note sagesig pulse width.
2023-06-07 Add openocd config.
2023-06-07 Add serial read script.
2023-06-08 Add system design docs & protocol docs.
2023-06-08 Tweak typesetting, add info.
2023-06-08 Add BRT error codes.
2023-06-08 Add DC-01 set state packet.
2023-06-08 Fix bad syntax
2023-06-08 Add mode & other basic variables definitions.
2023-06-08 Implement inputs debouncing (buttons & dcc).
2023-06-08 Fix doc.
2023-06-08 Send state to USB peridically.
2023-06-08 Make manual override mode work.
2023-06-08 Use blue LED for USB communication.
2023-06-08 Add mode indication.
2023-06-08 Receive data from USB, calculate timeout.
2023-06-08 Add separate resistors for LEDs.
2023-06-08 Tweak resistor values for LEDs.
2023-06-11 Group interrupt requests.
2023-06-11 Add selftest template.
2023-06-11 Implement brtest from & to transitions.
2023-06-11 Unify coding style, allow to set relays separately.
2023-06-11 Implement big relay test steps.
2023-06-11 Perform test after startup.
2023-06-12 Run brtest when appropriate.
2023-06-12 Run brtest only each xx minutes.
2023-06-12 Interrupt brtest if dcc lost.
2023-06-12 Disable brtest_request on test interrupt.
2023-06-12 Stop brtest on every appl change of relay state.
2023-06-12 Keep relays off after startup.
2023-06-13 Add serial RW utils.
2023-06-13 Add README & LICENSE.
2023-06-13 Add separate PCB readme.
2023-06-13 Move D12 & D13 to another position to keep isolation distance.
2023-08-18 All output pins control.
2023-08-18 Add proper error handler.
2023-08-18 Indicate selftest warnings.
2023-08-18 Add docstrings.
2023-08-18 Remove unused mBigRelayTest state.
2023-08-18 Avoid out-of-phase led flick.
2023-08-22 Add template of hjop_watchdog.py.
2023-08-22 Fix main timer period.
2023-08-22 hjop_watchdog: add communication with hJOPserver.
2023-08-22 hjop_watchdog: add mock option.
2023-08-22 Make hjop_watchdog work on Windows.
2023-08-22 hjop_watchdog: add types.
2023-08-22 hjop_watchdog: minor tweaks.
2023-08-22 Add top description.
2023-08-24 Tweak a4.tex.
2023-08-24 Increase DCC resistor value.
2023-08-24 Use handsolder footprint for 1206 fuses.
2023-09-01 hjop_watchdog: add proper getter.
2023-09-15 Implement info request.
2023-09-15 hjop_watchdog: ask DC-01 info at the beginning.
2023-09-15 hjop_watchdog: parse BRTest state.
2023-09-15 Cancel pending request when DCC should no more be connected.
    Never perform BRTest when DCC should be disconnected.
2023-09-16 Switch active-alert outputs.
2023-09-16 Tweak alert time (1s).
2023-09-23 Update README.
2023-10-07 Add docs diagram.
2023-10-07 Add product photos.
2023-10-14 hjop_watchdog: catch socket timeout.
2023-10-14 Log to stdout.
2023-10-14 hjop_watchdog: add -r switch, handle DC-01 disconnect.
2023-10-14 hjop_monitor: use 127.0.0.1 instead of localhost.
    It's much faster! 300 ms -> 50 ms.
2023-10-14 hjop_monitor: set loglevel based on received data.
2023-10-14 hjop_watchdog: add logging to file.
2023-11-02 Increase timeout to 2 s.
2023-11-02 Indicate timeout warnings via warnings report.
2023-12-22 Note acoustic warning parameters.
2023-12-26 Add link to czech article @ kmz-brno.cz.
2023-12-30 hjop_watchdog: add colorful output.
2024-01-14 Add images to aco-warn directory.
2024-04-01 Add '--nocolor' switch.
2024-04-01 Use color output only if device supports it.
2024-04-16 Add terminal color support for Windows.
2024-04-18 Remove debug print.
2026-02-06 Allow to activate relays back when red button pressed.
    ...by pressing green button.
2026-02-06 Bump FW version to v1.1.

Notices in the files:
pcb/dc01.kicad_pcb:
Released under the Creative Commons Attribution-ShareAlike 4.0 License
